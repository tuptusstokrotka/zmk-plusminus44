## config/boards/shields/plusminus44/Kconfig.defconfig
```kconfig
if SHIELD_PLUSMINUS44

config ZMK_KEYBOARD_NAME
    default "plusminus44"

endif
```
